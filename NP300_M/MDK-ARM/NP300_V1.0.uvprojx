# Keil uVision project NP300_V1.0.uvprojx, settings and files
target NP300_V1.0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: NP300_V1.0
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32L431xx,USE_HAL_DRIVER
  c include: ../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\app\inc;..\bsp\Inc;..\common\inc;..\os\bsp;..\os\components\finsh;..\os\include\libc;..\os\include;..\api\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group common
    ../common/src/: main.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c system_stm32l4xx.c
    ./: startup_stm32l431xx.s
  group bsp
    ../bsp/Src/: bsp_spi.c bsp_usart.c bsp_i2c.c bsp_log.c bsp_rtc.c bsp_adc.c
  group app/power
    ../APP/src/: app_drv_power.c app_srv_power.c
    ../app/src/: app_power_task.c
  group app/display
    ../APP/src/: app_drv_oled.c app_srv_oled.c
    ../app/src/: app_oled_task.c
  group app/sample
    ../app/src/: app_drv_sample.c app_srv_sample.c app_sample_task.c
  group app/finsh
    ../APP/src/: drv_uart.c ringbuffer.c
  group os/shell
    ../os/components/finsh/: cmd.c msh.c shell.c
  group os/kernel
    ../os/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../os/bsp/: rtconfig.h board.c
    ../os/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_ll_adc.c stm32l4xx_ll_exti.c stm32l4xx_ll_dma.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_rcc.c stm32l4xx_ll_usart.c stm32l4xx_ll_rtc.c stm32l4xx_ll_spi.c stm32l4xx_ll_utils.c stm32l4xx_ll_tim.c
software components: CMSIS:CORE 4.3.0
